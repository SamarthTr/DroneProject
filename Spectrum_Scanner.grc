options:
  parameters:
    author: Piyush Chandak
    description: This is a flowgraph that scans the spextrum band periodically
    generate_options: qt_gui
    id: Spectrum_Scanner
    output_language: python
    title: Frequency Scanner
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '70000000'
  states: {}
- name: freq1
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '65105'
  states: {}
- name: Centrefreqloop
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\r\nfrom gnuradio import gr\r\nfrom gnuradio import iio\r\nimport numpy as np\r\nclass center_freq_block(gr.sync_block):\r\n    def __init__(self, freq_start, freq_stop, freq_step):\r\n        gr.sync_block.__init__(self,\r\n            name=\"center_freq_block\",\r\n            in_sig=None,\r\n            out_sig=[np.float32])\r\n        self.freq_start = freq_start\r\n        self.freq_stop = freq_stop\r\n        self.freq_step = freq_step\r\n\r\n\r\n    def work(self, input_items, output_items):\r\n        out = output_items[0]\r\n        while self.freq_start <= self.freq_stop:\r\n            out = self.pluto_src.read()\r\n            self.freq_start += self.freq_step\r\n            self.pluto_src.set_frequency(self.freq_start)\r\n            time.sleep(0.1)\r\n        return len(out)\r\n\r\n# Create an instance of the block with start frequency = 70e6, stop frequency = 5e9, and step frequency = 10e6\r\ncenter_freq = center_freq_block(70e6, 5e9, 10e6)\r\n\r\n"
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '2400000000'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '2400000000'
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}

connections:
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
